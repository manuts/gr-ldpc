<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>example1</value></param>
<param><key>author</key><value>Manu T S</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>alist_file</value></param>
<param><key>value</key><value>"/home/manu/repos/ldpc/gr-ldpc/python/alist-files"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sigma</value></param>
<param><key>value</key><value>0.3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>max_iterations</value></param>
<param><key>value</key><value>50</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/manu/Downloads/in.flac</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/manu/Downloads/out.flac</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>ldpc_ldpc_hier_encoder_bf</key>
<param><key>id</key><value>ldpc_ldpc_hier_encoder_bf_0</value></param>
<param><key>alist_file</key><value>alist_file</value></param>
</block>
<block>
<key>ldpc_ldpc_hier_decoder_fb</key>
<param><key>id</key><value>ldpc_ldpc_hier_decoder_fb_0</value></param>
<param><key>alist_file</key><value>alist_file</value></param>
<param><key>sigma</key><value>sigma</value></param>
<param><key>max_iterations</key><value>max_iterations</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>ldpc_ldpc_hier_encoder_bf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ldpc_ldpc_hier_encoder_bf_0</source_block_id><sink_block_id>ldpc_ldpc_hier_decoder_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ldpc_ldpc_hier_decoder_fb_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
